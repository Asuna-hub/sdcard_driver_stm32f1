# Keil uVision project sdcard_driver.uvprojx, settings and files
target f103c8t6 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sdcard_driver
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=3
  c include: .\User\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./User/Source/: main.c rcc.c sdcard_spi.c systick.c
  group Include
    ./User/Include/: main.h rcc.h sdcard_spi.h systick.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
